options:
  parameters:
    author: surligas
    generate_options: qt_gui
    id: clamp
    output_language: python
    title: clamp
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Original (Real)
    label2: 'Original (Imag) '
    label3: Clamped (Real)
    label4: Clamped (Imag)
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tutorial_complex_clamp_0
  id: tutorial_complex_clamp
  parameters:
    threshold: '0.8'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', tutorial_complex_clamp_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [tutorial_complex_clamp_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
