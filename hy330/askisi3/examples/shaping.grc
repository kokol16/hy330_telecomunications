options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: analog_sig_source_x_0_3_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: '[1, 5, 1, 4]'
    label1: Without Shaping
    label2: With Shaping
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[1, 0, 1, 4]'
    label1: Without Shaping
    label2: With Shaping
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '505'
    samp_rate: '32'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}

connections:
- [analog_sig_source_x_0_3_1_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_3_1_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
