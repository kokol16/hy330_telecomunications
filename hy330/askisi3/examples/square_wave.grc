options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: f
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: variable_qtgui_check_box_0
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 0]'
    label: f
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_1
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 1]'
    label: 3xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 2]'
    label: 5xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_3
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0,3]'
    label: 7xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_4
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 4]'
    label: 9xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_5
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 5]'
    label: 11xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_check_box_6
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: '[0, 6]'
    label: 13xf
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 3*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 5*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 7*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 9*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_3_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 11*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_3_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 13*f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_3_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '7'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_1 * (1.0/3.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_2 * (1.0/5.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_3* (1.0/7.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_4* (1.0/9.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_5* (1.0/11.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_6* (1.0/13.0)
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: '[1, 5, 1, 4]'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[1, 0, 1, 4]'
    label1: ''
    label2: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_sig_source_x_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [analog_sig_source_x_0_3, '0', blocks_multiply_const_vxx_0_3, '0']
- [analog_sig_source_x_0_3_0, '0', blocks_multiply_const_vxx_0_3_0, '0']
- [analog_sig_source_x_0_3_1, '0', blocks_multiply_const_vxx_0_3_1, '0']
- [analog_sig_source_x_0_3_1_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0_3_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_3, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_3_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_3_1, '0', blocks_add_xx_0, '6']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
