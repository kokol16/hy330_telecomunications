options:
  parameters:
    author: gkokol
    generate_options: qt_gui
    id: gk
    output_language: python
    title: gkokol
  states: {}

blocks:
- name: constelation_mod
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constelation_mod
  states: {}
- name: constellation_mapping_constellation_mapping_0
  id: constellation_mapping_constellation_mapping
  parameters:
    k: constelation_mod
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', constellation_mapping_constellation_mapping_0, '0']
- [constellation_mapping_constellation_mapping_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
