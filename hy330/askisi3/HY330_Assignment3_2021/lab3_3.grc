options:
  parameters:
    author: gkokol
    generate_options: qt_gui
    id: gk
    output_language: python
    title: gkokol
  states: {}

blocks:
- name: constelation_mod
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gkokol/Documents/GitHub/hy330_telecomunications/hy330/askisi3/HY330_Assignment3_2021/test.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constelation_mod
  states: {}
- name: constelation_mapping_module_constelation_mapping_0
  id: constelation_mapping_module_constelation_mapping
  parameters:
    _k: constelation_mod
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', constelation_mapping_module_constelation_mapping_0, '0']
- [constelation_mapping_module_constelation_mapping_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
