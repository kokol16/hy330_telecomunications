options:
  parameters:
    author: Manolis Surligas
    generate_options: qt_gui
    id: psk_transceiver
    output_language: python
    title: PSK transceiver
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    comment: Samples per symbol
    value: int(math.log2(constellation.arity()))
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: '4'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    comment: |-
      Brings the amplitude of the signal into a known
      reference level. Try to disable it and see what is
      happening to the constellation points.
      Do we need it???!!!
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: math.sqrt(2)/2
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '100'
    msg: pmt.intern("TEST")
    std: '100'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '128'
    minsize: '100'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 8*sps
    comment: |-
      Necessary for proper transmission with
      SDR hardware. Do not care about it!
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      This block is needed to convert the input stream that
      constaines log2(constellation size) bits per byte into
      a stream of 1 bit per byte. This will greatly simplify
      the logic of your frame synchronization regardless
      of the actual modulation used by the system.
      Keep it stupid simple!
    k: bits_per_symbol
  states: {}
- name: channels_dynamic_channel_model_0
  id: channels_dynamic_channel_model
  parameters:
    LOS: 'False'
    N: '8'
    cfo_maxdev: 1e3
    cfo_stdev: '0.01'
    comment: |-
      Add hardware and channel impairements.
      Disable it during initial development or reduce
      the noise and the frequency offset. As you 
      procceeding with the development start
      experimenting with larger values of frequency
      offset and noise amplitude.

      Remeber, wireless channels are pretty nasty and challenging!
    delays: '[0.0,0.1,1.3]'
    fD: '50.0'
    mags: '[1,0.99,0.97]'
    noise_amp: '0.1'
    ntaps: '8'
    samp_rate: samp_rate
    seed: '0'
    sro_maxdev: 1e3
    sro_stdev: '0.01'
  states: {}
- name: cs330project_constellation_modulator_0
  id: cs330project_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: cs330project_deinterleaver_0
  id: cs330project_deinterleaver
  parameters:
    block_size: '96'
  states: {}
- name: cs330project_fec_decoder_0
  id: cs330project_fec_decoder
  parameters:
    fec_type: No FEC
  states: {}
- name: cs330project_fec_encoder_0
  id: cs330project_fec_encoder
  parameters:
    fec_type: No FEC
  states: {}
- name: cs330project_frame_sync_0
  id: cs330project_frame_sync
  parameters:
    mod: '0'
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project_framer_0
  id: cs330project_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project_interleaver_0
  id: cs330project_interleaver
  parameters:
    block_size: '96'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    comment: |-
      Necessary for proper transmission with
      SDR hardware. It prepends and appends some 
      zero samples for every frame. Do not care about it!
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '1000'
    pre_padding: '1000'
    type: complex
    window: ([])
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Performs frequency synchronization
       (stops the rotation of PSK symbols)
      and demaps the received constellation
       points into bits
    constellation: constellation
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2.0 * math.pi/100.0
    showports: 'True'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      Black magic. Many poor souls died trying to
      understand the black sorcery that hides behind
      this block.

      The goal of this block is to minimize ISI, introduced by wrong
      sampling timing (clocks of TX and RX are not in sync)
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2.0 * math.pi/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Without impairements"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"With impairements"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_random_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pdu_to_tagged_stream_0, '0', cs330project_constellation_modulator_0, '0']
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_socket_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_tagged_stream_multiply_length_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', cs330project_frame_sync_0, '0']
- [channels_dynamic_channel_model_0, '0', analog_agc2_xx_0, '0']
- [channels_dynamic_channel_model_0, '0', qtgui_freq_sink_x_0_0, '0']
- [cs330project_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [cs330project_deinterleaver_0, pdu_out, cs330project_fec_decoder_0, pdu_in]
- [cs330project_fec_decoder_0, pdu_out, digital_crc32_async_bb_0_0, in]
- [cs330project_fec_encoder_0, pdu_out, cs330project_interleaver_0, pdu_in]
- [cs330project_frame_sync_0, pdu, cs330project_deinterleaver_0, pdu_in]
- [cs330project_framer_0, frame, blocks_pdu_to_tagged_stream_0, pdus]
- [cs330project_interleaver_0, pdu_out, cs330project_framer_0, pdu]
- [digital_burst_shaper_xx_0, '0', channels_dynamic_channel_model_0, '0']
- [digital_burst_shaper_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_crc32_async_bb_0, out, cs330project_fec_encoder_0, pdu_in]
- [digital_crc32_async_bb_0_0, out, blocks_message_debug_0, print_pdu]
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']

metadata:
  file_format: 1
