options:
  parameters:
    author: Manolis Surligas
    generate_options: qt_gui
    id: psk_transceiver
    output_language: python
    title: PSK transceiver
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    comment: Samples per symbol
    value: int(math.log2(constellation.arity()))
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '100'
    msg: pmt.intern("TEST")
    std: '100'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '128'
    minsize: '100'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: cs330project_fec_encoder_0
  id: cs330project_fec_encoder
  parameters:
    fec_type: No FEC
  states: {}
- name: cs330project_frame_sync_0
  id: cs330project_frame_sync
  parameters:
    mod: '0'
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project_framer_0
  id: cs330project_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project_interleaver_0
  id: cs330project_interleaver
  parameters:
    block_size: '96'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, blocks_random_pdu_0, generate]
- [blocks_packed_to_unpacked_xx_0, '0', cs330project_frame_sync_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_socket_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [cs330project_fec_encoder_0, pdu_out, cs330project_interleaver_0, pdu_in]
- [cs330project_frame_sync_0, pdu, digital_crc32_async_bb_0_0, in]
- [cs330project_framer_0, frame, blocks_pdu_to_tagged_stream_0, pdus]
- [cs330project_interleaver_0, pdu_out, cs330project_framer_0, pdu]
- [digital_crc32_async_bb_0, out, cs330project_fec_encoder_0, pdu_in]
- [digital_crc32_async_bb_0_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
