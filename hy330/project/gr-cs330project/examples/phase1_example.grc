options:
  parameters:
    author: mraptakis
    generate_options: qt_gui
    id: phase1_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '100'
    msg: pmt.intern("TEST")
    std: '100'
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '128'
    minsize: '100'
  states: {}
- name: cs330project_framer_0
  id: cs330project_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, blocks_random_pdu_0, generate]
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [cs330project_framer_0, frame, blocks_message_debug_0, print_pdu]
- [digital_crc32_async_bb_0, out, cs330project_framer_0, pdu]

metadata:
  file_format: 1
