options:
  parameters:
    author: mraptakis
    generate_options: qt_gui
    id: phase2_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    comment: Samples per symbol
    value: int(math.log2(constellation.arity()))
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '100'
    msg: pmt.intern("TEST")
    std: '100'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bits_per_symbol
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '128'
    minsize: '100'
  states: {}
- name: cs330project_fec_decoder_0
  id: cs330project_fec_decoder
  parameters:
    fec_type: Hamming
  states: {}
- name: cs330project_fec_encoder_0
  id: cs330project_fec_encoder
  parameters:
    fec_type: Hamming
  states: {}
- name: cs330project_frame_sync_0
  id: cs330project_frame_sync
  parameters:
    mod: '1'
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project_framer_0
  id: cs330project_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_0_0_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[2,0,3,1]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, blocks_random_pdu_0, generate]
- [blocks_packed_to_unpacked_xx_0, '0', digital_map_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_random_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [cs330project_fec_decoder_0, pdu_out, digital_crc32_async_bb_0_0_0, in]
- [cs330project_fec_encoder_0, pdu_out, cs330project_framer_0, pdu]
- [cs330project_frame_sync_0, pdu, cs330project_fec_decoder_0, pdu_in]
- [cs330project_framer_0, frame, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_crc32_async_bb_0, out, cs330project_fec_encoder_0, pdu_in]
- [digital_crc32_async_bb_0_0_0, out, blocks_message_debug_0_0_0, print_pdu]
- [digital_map_bb_0, '0', cs330project_frame_sync_0, '0']

metadata:
  file_format: 1
